Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: d5da675d-a4a4-4104-bdbf-8d04c3a6ef08, NumberOfSaves: 1]
File name: 0001
Time: 2026-09-10T21:28:58+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12665220_EU1_KFN7833D:38783300_EU1_12665220_KFN7833D, (2)
In: Default
Type - Material: z_Miele_Design_BRWS, <Unnamed>, z_Miele_Design_Glass Black, z_Miele_Design_Zinc_Steel, z_Miele_Design_Glass, z_Miele_Connection_Electric
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 541 mm; Height: 1938 mm; Depth: 545 mm
Pset_BuildingElementProxyCommon - Reference: 38783300_EU1_12665220_KFN7833D; sets with these values: 2

# IfcDistributionPort, Port_354329_1
Description: Flow; FlowDirection: SOURCEANDSINK
